# Keil uVision project msOS.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: msOS +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\SourceFile;..\SourceFile\App;..\SourceFile\System;..\SourceFile\System\OS;..\SourceFile\System\GUI;..\SourceFile\System\Modbus;..\SourceFile\System\Device;..\SourceFile\System\Device\Drive;..\SourceFile\System\Device\Drive\CMSIS;..\SourceFile\System\Device\Drive\LIB\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../SourceFile/App/: app.c logic.c menu.c
  group System
    ../SourceFile/System/: system.h system.c
  group System.Os
    ../SourceFile/System/OS/: os.c
  group System.Gui
    ../SourceFile/System/GUI/: gui.c
  group System.Modbus
    ../SourceFile/System/Modbus/: modbus.c modbus_slave.c
  group System.Device
    ../SourceFile/System/Device/: device.c device.h device_adc.c device_di.c device_do.c device_key.c device_lcd.c device_rtc.c device_timer.c device_storage.c device_systick.c device_usart1.c device_usart2.c device_misc.c
  group System.Device.Drive
    ../SourceFile/System/Device/Drive/: drive.h stm32f10x_conf.h
  group System.Device.Drive.Cmsis
    ../SourceFile/System/Device/Drive/CMSIS/: core_cm3.c system_stm32f10x.c
    ../SourceFile/System/Device/Drive/CMSIS/STARTUP/: startup_stm32f10x_md.s
  group System.Device.Drive.Lib
    ../SourceFile/System/Device/Drive/LIB/src/: stm32f10x_usart.c misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c
